Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Soha Jardinière grand modèle.IFC
Time: 2020-05-06T06:16:21
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: Boss.-Extru.2[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss.-Extru.2[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss.-Extru.2[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Boss.-Extru.2[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Enlèv. mat.-Extru.2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Enlèv. mat.-Extru.3[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Enlèv. mat.-Extru.3[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: FISCHER-ET12x30_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: MULT-JAR-002_Default
In: Default Storey
PredefinedType: ELEMENT; Material: PE

# IfcBuildingElementProxy: MULT-JAR-003_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: MULT-JAR-006_Petit Modèle
In: Default Storey
PredefinedType: ELEMENT; Material: S235 galva

# IfcBuildingElementProxy: SOHA-JAR-GM-002_Default
In: Default Storey
PredefinedType: ELEMENT; Material: S235 galva

# IfcBuildingElementProxy: SOHA-JAR-MUL-001-01_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: TFil-M20x100-A2_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
